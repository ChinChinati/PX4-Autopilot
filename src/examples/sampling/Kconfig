## src/examples/sampling/Kconfig
```kconfig
menuconfig EXAMPLES_SAMPLING
	bool "sampling"
	default n
	---help---
		Enable support for sampling
```
